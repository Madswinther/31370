# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: virtual_com.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config\LPC2478_SDRAM.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Custom libs
    Custom libs/: animation.c animation.h gui.c gui.h layout.c layout.h parsing.c parsing.h uart.c uart.h
  group Custom libs/graphics
    Custom libs/: draw.c draw.h
    Custom libs/graphics/: graph.c graph.h ProgressBar.c ProgressBar.h ProgressSpinner.c ProgressSpinner.h
  group Custom libs/Pages
    Custom libs/Pages/: devicespage.c devicespage.h graphpage.c graphpage.h learningpage.c learningpage.h mainpage.c mainpage.h navigationbar.c navigationbar.h
  group Modules
    board/: sys.c
  group Modules/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules/GLCD
    modules/: drv_glcd.c
  group Modules/SDRAM
    modules/: sdram_64M_32bit_drv.c
  group Modules/TOUCHSCREEN
    modules/: drv_touch_scr.c drv_touch_scr.h
